FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-boot-domain-as-one-fat-commit.patch \
    "
