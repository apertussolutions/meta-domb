require xen-version.inc
